#include "oled_display.h"
#include "config.h"
#include <Wire.h>
#include <avr/pgmspace.h>
#include <stdio.h>
#include <string.h>

namespace {

constexpr uint8_t OLED_WIDTH = 128;
constexpr uint8_t OLED_PAGES = 4; // 32 pixels / 8 pixels per page

// Compact 5x7 ASCII font (characters 0x20 ' ' through 0x7E '~'), stored in Flash.
const uint8_t FONT_5X7[][5] PROGMEM = {
    {0x00, 0x00, 0x00, 0x00, 0x00}, // ' ' 0x20
    {0x00, 0x00, 0x5F, 0x00, 0x00}, // '!'
    {0x00, 0x07, 0x00, 0x07, 0x00}, // '"'
    {0x14, 0x7F, 0x14, 0x7F, 0x14}, // '#'
    {0x24, 0x2A, 0x7F, 0x2A, 0x12}, // '$'
    {0x23, 0x13, 0x08, 0x64, 0x62}, // '%'
    {0x36, 0x49, 0x55, 0x22, 0x50}, // '&'
    {0x00, 0x05, 0x03, 0x00, 0x00}, // '''
    {0x00, 0x1C, 0x22, 0x41, 0x00}, // '('
    {0x00, 0x41, 0x22, 0x1C, 0x00}, // ')'
    {0x14, 0x08, 0x3E, 0x08, 0x14}, // '*'
    {0x08, 0x08, 0x3E, 0x08, 0x08}, // '+'
    {0x00, 0x50, 0x30, 0x00, 0x00}, // ','
    {0x08, 0x08, 0x08, 0x08, 0x08}, // '-'
    {0x00, 0x60, 0x60, 0x00, 0x00}, // '.'
    {0x20, 0x10, 0x08, 0x04, 0x02}, // '/'
    {0x3E, 0x51, 0x49, 0x45, 0x3E}, // '0'
    {0x00, 0x42, 0x7F, 0x40, 0x00}, // '1'
    {0x42, 0x61, 0x51, 0x49, 0x46}, // '2'
    {0x21, 0x41, 0x45, 0x4B, 0x31}, // '3'
    {0x18, 0x14, 0x12, 0x7F, 0x10}, // '4'
    {0x27, 0x45, 0x45, 0x45, 0x39}, // '5'
    {0x3C, 0x4A, 0x49, 0x49, 0x30}, // '6'
    {0x01, 0x71, 0x09, 0x05, 0x03}, // '7'
    {0x36, 0x49, 0x49, 0x49, 0x36}, // '8'
    {0x06, 0x49, 0x49, 0x29, 0x1E}, // '9'
    {0x00, 0x36, 0x36, 0x00, 0x00}, // ':'
    {0x00, 0x56, 0x36, 0x00, 0x00}, // ';'
    {0x08, 0x14, 0x22, 0x41, 0x00}, // '<'
    {0x14, 0x14, 0x14, 0x14, 0x14}, // '='
    {0x00, 0x41, 0x22, 0x14, 0x08}, // '>'
    {0x02, 0x01, 0x51, 0x09, 0x06}, // '?'
    {0x32, 0x49, 0x79, 0x41, 0x3E}, // '@'
    {0x7E, 0x11, 0x11, 0x11, 0x7E}, // 'A'
    {0x7F, 0x49, 0x49, 0x49, 0x36}, // 'B'
    {0x3E, 0x41, 0x41, 0x41, 0x22}, // 'C'
    {0x7F, 0x41, 0x41, 0x22, 0x1C}, // 'D'
    {0x7F, 0x49, 0x49, 0x49, 0x41}, // 'E'
    {0x7F, 0x09, 0x09, 0x09, 0x01}, // 'F'
    {0x3E, 0x41, 0x49, 0x49, 0x7A}, // 'G'
    {0x7F, 0x08, 0x08, 0x08, 0x7F}, // 'H'
    {0x00, 0x41, 0x7F, 0x41, 0x00}, // 'I'
    {0x20, 0x40, 0x41, 0x3F, 0x01}, // 'J'
    {0x7F, 0x08, 0x14, 0x22, 0x41}, // 'K'
    {0x7F, 0x40, 0x40, 0x40, 0x40}, // 'L'
    {0x7F, 0x02, 0x0C, 0x02, 0x7F}, // 'M'
    {0x7F, 0x04, 0x08, 0x10, 0x7F}, // 'N'
    {0x3E, 0x41, 0x41, 0x41, 0x3E}, // 'O'
    {0x7F, 0x09, 0x09, 0x09, 0x06}, // 'P'
    {0x3E, 0x41, 0x51, 0x21, 0x5E}, // 'Q'
    {0x7F, 0x09, 0x19, 0x29, 0x46}, // 'R'
    {0x46, 0x49, 0x49, 0x49, 0x31}, // 'S'
    {0x01, 0x01, 0x7F, 0x01, 0x01}, // 'T'
    {0x3F, 0x40, 0x40, 0x40, 0x3F}, // 'U'
    {0x1F, 0x20, 0x40, 0x20, 0x1F}, // 'V'
    {0x3F, 0x40, 0x38, 0x40, 0x3F}, // 'W'
    {0x63, 0x14, 0x08, 0x14, 0x63}, // 'X'
    {0x07, 0x08, 0x70, 0x08, 0x07}, // 'Y'
    {0x61, 0x51, 0x49, 0x45, 0x43}, // 'Z'
    {0x00, 0x7F, 0x41, 0x41, 0x00}, // '['
    {0x02, 0x04, 0x08, 0x10, 0x20}, // '\'
    {0x00, 0x41, 0x41, 0x7F, 0x00}, // ']'
    {0x04, 0x02, 0x01, 0x02, 0x04}, // '^'
    {0x40, 0x40, 0x40, 0x40, 0x40}, // '_'
    {0x00, 0x01, 0x02, 0x04, 0x00}, // '`'
    {0x20, 0x54, 0x54, 0x54, 0x78}, // 'a'
    {0x7F, 0x48, 0x44, 0x44, 0x38}, // 'b'
    {0x38, 0x44, 0x44, 0x44, 0x20}, // 'c'
    {0x38, 0x44, 0x44, 0x48, 0x7F}, // 'd'
    {0x38, 0x54, 0x54, 0x54, 0x18}, // 'e'
    {0x08, 0x7E, 0x09, 0x01, 0x02}, // 'f'
    {0x0C, 0x52, 0x52, 0x52, 0x3E}, // 'g'
    {0x7F, 0x08, 0x04, 0x04, 0x78}, // 'h'
    {0x00, 0x44, 0x7D, 0x40, 0x00}, // 'i'
    {0x20, 0x40, 0x44, 0x3D, 0x00}, // 'j'
    {0x7F, 0x10, 0x28, 0x44, 0x00}, // 'k'
    {0x00, 0x41, 0x7F, 0x40, 0x00}, // 'l'
    {0x7C, 0x04, 0x18, 0x04, 0x78}, // 'm'
    {0x7C, 0x08, 0x04, 0x04, 0x78}, // 'n'
    {0x38, 0x44, 0x44, 0x44, 0x38}, // 'o'
    {0x7C, 0x14, 0x14, 0x14, 0x08}, // 'p'
    {0x08, 0x14, 0x14, 0x18, 0x7C}, // 'q'
    {0x7C, 0x08, 0x04, 0x04, 0x08}, // 'r'
    {0x48, 0x54, 0x54, 0x54, 0x20}, // 's'
    {0x04, 0x3F, 0x44, 0x40, 0x20}, // 't'
    {0x3C, 0x40, 0x40, 0x20, 0x7C}, // 'u'
    {0x1C, 0x20, 0x40, 0x20, 0x1C}, // 'v'
    {0x3C, 0x40, 0x30, 0x40, 0x3C}, // 'w'
    {0x44, 0x28, 0x10, 0x28, 0x44}, // 'x'
    {0x0C, 0x50, 0x50, 0x50, 0x3C}, // 'y'
    {0x44, 0x64, 0x54, 0x4C, 0x44}, // 'z'
    {0x00, 0x08, 0x36, 0x41, 0x00}, // '{'
    {0x00, 0x00, 0x7F, 0x00, 0x00}, // '|'
    {0x00, 0x41, 0x36, 0x08, 0x00}, // '}'
    {0x10, 0x08, 0x08, 0x10, 0x08}  // '~'
};

const uint8_t INIT_SEQ[] PROGMEM = {
    0xAE,       // Display OFF
    0xD5, 0x80, // Set display clock divide ratio
    0xA8, 0x1F, // Multiplex ratio = 31 (32 rows)
    0xD3, 0x00, // Display offset = 0
    0x40,       // Start line = 0
    0x8D, 0x14, // Charge pump ON
    0x20, 0x02, // Page addressing mode
    0xA1,       // Segment remap (col 127 mapped to SEG0)
    0xC8,       // COM scan direction remapped
    0xDA, 0x02, // COM pins hardware config for 128x32
    0x81, 0x8F, // Contrast
    0xD9, 0xF1, // Pre-charge period
    0xDB, 0x40, // VCOMH deselect level
    0xA4,       // Entire display ON resumes from RAM
    0xA6,       // Normal display (not inverted)
    0xAF        // Display ON
};

uint8_t getGlyphByte(char c, uint8_t col) {
    if (c < 0x20 || c > 0x7E) {
        c = ' ';
    }
    return pgm_read_byte(&FONT_5X7[c - 0x20][col]);
}

} // namespace

OledDisplay::OledDisplay() : present(false), onYield(nullptr) {}

void OledDisplay::serviceYield() {
    if (onYield) {
        onYield();
    }
}

bool OledDisplay::begin(YieldCallback yieldCb) {
    onYield = yieldCb;
    Wire.begin();
    Wire.setClock(400000); // Fast-mode I2C minimizes blocking time

    Wire.beginTransmission(OLED_I2C_ADDR);
    if (Wire.endTransmission() != 0) {
        present = false;
        return false;
    }

    present = true;
    for (uint8_t i = 0; i < sizeof(INIT_SEQ); i++) {
        sendCommand(pgm_read_byte(&INIT_SEQ[i]));
    }

    for (uint8_t p = 0; p < OLED_PAGES; p++) {
        clearPage(p);
    }
    return true;
}

void OledDisplay::sendCommand(uint8_t cmd) {
    Wire.beginTransmission(OLED_I2C_ADDR);
    Wire.write(0x00); // Co=0, D/C#=0 (command)
    Wire.write(cmd);
    Wire.endTransmission();
}

void OledDisplay::sendCommands(const uint8_t* cmds, uint8_t len) {
    Wire.beginTransmission(OLED_I2C_ADDR);
    Wire.write(0x00);
    for (uint8_t i = 0; i < len; i++) {
        Wire.write(cmds[i]);
    }
    Wire.endTransmission();
}

void OledDisplay::setPageColumn(uint8_t page, uint8_t col) {
    uint8_t cmds[3] = {
        static_cast<uint8_t>(0xB0 | (page & 0x07)),
        static_cast<uint8_t>(col & 0x0F),
        static_cast<uint8_t>(0x10 | ((col >> 4) & 0x0F))
    };
    sendCommands(cmds, 3);
}

void OledDisplay::clearPage(uint8_t page) {
    setPageColumn(page, 0);
    // Send in 16-byte chunks (safe for AVR Wire 32-byte TX buffer)
    for (uint8_t col = 0; col < OLED_WIDTH; col += 16) {
        Wire.beginTransmission(OLED_I2C_ADDR);
        Wire.write(0x40); // Data
        for (uint8_t i = 0; i < 16; i++) {
            Wire.write(0x00);
        }
        Wire.endTransmission();
        serviceYield();
    }
}

void OledDisplay::drawCenteredTextPage(uint8_t page, const char* text) {
    size_t len = text ? strlen(text) : 0;
    if (len > 21) {
        len = 21; // Max 21 chars * 6px = 126px
    }
    uint8_t textWidth = static_cast<uint8_t>(len * 6);
    uint8_t startCol = (OLED_WIDTH - textWidth) / 2;

    setPageColumn(page, 0);
    uint8_t col = 0;
    while (col < OLED_WIDTH) {
        Wire.beginTransmission(OLED_I2C_ADDR);
        Wire.write(0x40);
        uint8_t chunk = 0;
        while (col < OLED_WIDTH && chunk < 16) {
            uint8_t pixelCol = 0x00;
            if (col >= startCol && col < startCol + textWidth) {
                uint8_t offset = col - startCol;
                uint8_t charIdx = offset / 6;
                uint8_t glyphCol = offset % 6;
                if (glyphCol < 5) {
                    pixelCol = getGlyphByte(text[charIdx], glyphCol);
                }
            }
            Wire.write(pixelCol);
            col++;
            chunk++;
        }
        Wire.endTransmission();
        serviceYield();
    }
}

void OledDisplay::showLines(const char* line1, const char* line2) {
    if (!present) {
        return;
    }

    if (line2 == nullptr || line2[0] == '\0') {
        clearPage(0);
        drawCenteredTextPage(1, line1);
        clearPage(2);
        clearPage(3);
    } else {
        drawCenteredTextPage(0, line1);
        clearPage(1);
        drawCenteredTextPage(2, line2);
        clearPage(3);
    }
}

void OledDisplay::showProgress(int percent) {
    if (!present) {
        return;
    }

    if (percent < 0) percent = 0;
    if (percent > 100) percent = 100;

    char label[12];
    snprintf(label, sizeof(label), "Drawing %d%%", percent);
    drawCenteredTextPage(0, label);
    clearPage(1);

    // Draw bordered progress bar on page 2 (x = 8..119, inner = 10..117 -> 108px)
    constexpr uint8_t BAR_X0 = 8;
    constexpr uint8_t BAR_X1 = 119;
    uint8_t fillEnd = BAR_X0 + 2 + static_cast<uint8_t>((static_cast<uint16_t>(BAR_X1 - BAR_X0 - 3) * percent) / 100);

    setPageColumn(2, 0);
    uint8_t col = 0;
    while (col < OLED_WIDTH) {
        Wire.beginTransmission(OLED_I2C_ADDR);
        Wire.write(0x40);
        uint8_t chunk = 0;
        while (col < OLED_WIDTH && chunk < 16) {
            uint8_t b = 0x00;
            if (col == BAR_X0 || col == BAR_X1) {
                b = 0x7E; // Left / right border
            } else if (col > BAR_X0 && col < BAR_X1) {
                b = 0x42; // Top & bottom border
                if (col >= BAR_X0 + 2 && col < fillEnd) {
                    b |= 0x3C; // Filled interior
                }
            }
            Wire.write(b);
            col++;
            chunk++;
        }
        Wire.endTransmission();
        serviceYield();
    }
    clearPage(3);
}
